FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0001-ClockGen-156-25Mhz-programming.patch"
