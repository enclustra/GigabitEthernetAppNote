FILESEXTRAPATHS:prepend := "${THISDIR}/files:"
SRC_URI:append = " file://0002-ClockGen-156-25Mhz-programming.patch"