IMAGE_INSTALL:append = " sysstat"
